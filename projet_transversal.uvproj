# Keil uVision project projet_transversal.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F020 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: projet_transversal
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c config_globale.c Declarations_GPIO_BSE.h config_UART.c FO_M1_Structures_COMMANDES_INFORMATIONS_CentraleDeCommande.C CFG_Globale.h UART0_RingBuffer_lib.C UART0_RingBuffer_lib.h
