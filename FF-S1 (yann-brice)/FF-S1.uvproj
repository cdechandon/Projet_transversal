# Keil uVision project FF-S1.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F020 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: FF-S1
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 Main.c Commande_Lumiere.c Declarations_GPIO_BSE.h Commande_Lumiere.h Config_Initiale.c Config_GPIO.c
